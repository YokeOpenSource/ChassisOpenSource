# Keil uVision project MC.uvprojx, settings and files
target MC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MC +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\User;..\module;..\app;..\hal;..\algorithm;..\module_chasis;..\module_mpu6050\DMP;..\module_mpu6050\MPU6050;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\module_vehicle;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Task;..\module_sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ST_Libraries
    ../Libraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c startup_stm32f4xx.s
  group BSP
    ../hal/: ad.c beep.c can2.c led.c DIO.c usart3.c usart1.c
    ../HAL/: pwm.c IIC.c spi.c encoder.c stmflash.c usart2_ringbuf.lib
  group module
    ../module/: module_ad.c module_beep.c module_led.c module_remoter.c module_ps2_remoter.c
  group module_chasis
    ../module_chasis/: module_motor_control.c
  group User
    ../User/: stm32f4xx_it.c main.c
  group algorithm
    ../algorithm/: pid.c ringbuffer.lib
  group module_mpu
    ../module_mpu6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../module_mpu6050/MPU6050/: MPU6050.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group module_vehicle
    ../module_vehicle/: module_vehicle.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Task
    ../Task/: SensorTask.c SerialCtrlTask.c CanCtrlTask.c RemoterCtrlTask.c
  group module_sensor
    ../module_sensor/: SR73_Radar.c
software components: CMSIS:CORE 5.0.0
